# Keil uVision project PROJ.uvprojx, settings and files
target PROJ (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PROJ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User\lcd;..\..\User\dht11;..\..\User\SysTick;..\..\User\keyboard;..\..\User\usart;..\..\User\ESP8266;..\..\User\Common;..\..\User\blt;..\..\User\pwm;..\..\User\photoresistor;..\..\User\sccb;..\..\User\FATFS;..\..\User\ov7725;..\..\User\sdio;..\..\User\bmp;..\..\User\FATFS\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_it.c main.c utility.c utility.h stm32f10x_conf.h
    ../../User/lcd/: ascii.h lcd.c lcd.h
    ../../User/dht11/: dht.h dht.c
    ../../User/keyboard/: keyboard.c keyboard.h
    ../../User/Common/: Common.c Common.h
    ../../User/SysTick/: bsp_SysTick.c bsp_SysTick.h
    ../../User/blt/: bsp_hc05.c bsp_hc05.h
    ../../User/usart/: bsp_usart.c bsp_usart.h bsp_usart_blt.h bsp_usart_blt.c
    ../../User/pwm/: pwm.h pwm.c
    ../../User/photoresistor/: phores.h phores.c
    ../../User/ESP8266/: bsp_esp8266.c bsp_esp8266.h
    ../../User/bmp/: bsp_bmp.c
    ../../User/FATFS/: ff.c diskio.c
    ../../User/FATFS/option/: ccsbcs.c
    ../../User/ov7725/: bsp_ov7725.c bsp_sccb.c
    ../../User/sdio/: sdio_test.c bsp_sdio_sdcard.c
    ../../User/led/: bsp_led.c
